* NGSPICE file created from mult_sec_32.ext - technology: sky130A

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_2 abstract view
.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand2_1 abstract view
.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_6 abstract view
.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_ef_sc_hd__decap_12 abstract view
.subckt sky130_ef_sc_hd__decap_12 VGND VPWR VPB VNB
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_1 abstract view
.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_4 abstract view
.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_1 abstract view
.subckt sky130_fd_sc_hd__fill_1 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_3 abstract view
.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_1 abstract view
.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dfxtp_2 abstract view
.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__fill_2 abstract view
.subckt sky130_fd_sc_hd__fill_2 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__decap_8 abstract view
.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21a_1 abstract view
.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlygate4sd3_1 abstract view
.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2_1 abstract view
.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor2_1 abstract view
.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_2 abstract view
.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_1 abstract view
.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_4 abstract view
.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__tapvpwrvgnd_1 abstract view
.subckt sky130_fd_sc_hd__tapvpwrvgnd_1 VGND VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2_1 abstract view
.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__inv_2 abstract view
.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_16 abstract view
.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a221o_1 abstract view
.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__mux2_1 abstract view
.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21boi_1 abstract view
.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_2 abstract view
.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31o_1 abstract view
.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o311a_1 abstract view
.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__clkbuf_1 abstract view
.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o221a_1 abstract view
.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xnor2_2 abstract view
.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o31a_1 abstract view
.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21o_1 abstract view
.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3_1 abstract view
.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or2b_1 abstract view
.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ba_1 abstract view
.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_1 abstract view
.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o211a_1 abstract view
.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nor3_1 abstract view
.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a211o_1 abstract view
.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and4_1 abstract view
.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a31oi_1 abstract view
.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3b_1 abstract view
.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_1 abstract view
.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_4 abstract view
.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__xor2_1 abstract view
.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__buf_1 abstract view
.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and3b_1 abstract view
.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__dlymetal6s2s_1 abstract view
.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o22a_1 abstract view
.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__nand3_1 abstract view
.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or4_1 abstract view
.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2111o_1 abstract view
.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a2bb2o_1 abstract view
.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a311o_2 abstract view
.subckt sky130_fd_sc_hd__a311o_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21oi_2 abstract view
.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__o21ai_2 abstract view
.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__and2b_1 abstract view
.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__or3_1 abstract view
.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__diode_2 abstract view
.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
.ends

* Black-box entry subcircuit for sky130_fd_sc_hd__a21bo_2 abstract view
.subckt sky130_fd_sc_hd__a21bo_2 A1 A2 B1_N VGND VNB VPB VPWR X
.ends

.subckt mult_sec_32 VGND VPWR clk done mcand[0] mcand[10] mcand[11] mcand[12] mcand[13]
+ mcand[14] mcand[15] mcand[16] mcand[17] mcand[18] mcand[19] mcand[1] mcand[20] mcand[21]
+ mcand[22] mcand[23] mcand[24] mcand[25] mcand[26] mcand[27] mcand[28] mcand[29]
+ mcand[2] mcand[30] mcand[31] mcand[3] mcand[4] mcand[5] mcand[6] mcand[7] mcand[8]
+ mcand[9] mplier[0] mplier[10] mplier[11] mplier[12] mplier[13] mplier[14] mplier[15]
+ mplier[16] mplier[17] mplier[18] mplier[19] mplier[1] mplier[20] mplier[21] mplier[22]
+ mplier[23] mplier[24] mplier[25] mplier[26] mplier[27] mplier[28] mplier[29] mplier[2]
+ mplier[30] mplier[31] mplier[3] mplier[4] mplier[5] mplier[6] mplier[7] mplier[8]
+ mplier[9] product[0] product[10] product[11] product[12] product[13] product[14]
+ product[15] product[16] product[17] product[18] product[19] product[1] product[20]
+ product[21] product[22] product[23] product[24] product[25] product[26] product[27]
+ product[28] product[29] product[2] product[30] product[31] product[32] product[33]
+ product[34] product[35] product[36] product[37] product[38] product[39] product[3]
+ product[40] product[41] product[42] product[43] product[44] product[45] product[46]
+ product[47] product[48] product[49] product[4] product[50] product[51] product[52]
+ product[53] product[54] product[55] product[56] product[57] product[58] product[59]
+ product[5] product[60] product[61] product[62] product[63] product[6] product[7]
+ product[8] product[9] st
X_432_ estado_act\[1\] estado_act\[0\] VGND VGND VPWR VPWR _075_ sky130_fd_sc_hd__nor2_2
X_501_ _135_ _136_ VGND VGND VPWR VPWR _137_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_94 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_895_ clknet_3_2__leaf_clk _036_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_680_ _295_ _296_ _297_ VGND VGND VPWR VPWR _298_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_33_150 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_878_ clknet_3_7__leaf_clk _019_ VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_16_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_801_ net165 _390_ _396_ VGND VGND VPWR VPWR _047_ sky130_fd_sc_hd__o21a_1
Xhold30 _424_ VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__dlygate4sd3_1
Xhold41 net127 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__dlygate4sd3_1
X_732_ _177_ _344_ VGND VGND VPWR VPWR _345_ sky130_fd_sc_hd__and2_1
XFILLER_0_26_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_663_ _095_ _282_ VGND VGND VPWR VPWR _283_ sky130_fd_sc_hd__nor2_1
X_594_ _177_ _220_ VGND VGND VPWR VPWR _221_ sky130_fd_sc_hd__and2_1
XFILLER_0_21_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_8_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_72 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_7_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput75 net75 VGND VGND VPWR VPWR product[17] sky130_fd_sc_hd__buf_2
X_715_ _327_ _328_ VGND VGND VPWR VPWR _329_ sky130_fd_sc_hd__xnor2_1
Xoutput97 net97 VGND VGND VPWR VPWR product[37] sky130_fd_sc_hd__buf_2
Xoutput86 net86 VGND VGND VPWR VPWR product[27] sky130_fd_sc_hd__clkbuf_4
X_646_ _265_ _266_ VGND VGND VPWR VPWR _267_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_26_170 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_577_ _177_ _205_ VGND VGND VPWR VPWR _206_ sky130_fd_sc_hd__and2_1
XFILLER_0_27_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_500_ net97 net28 VGND VGND VPWR VPWR _136_ sky130_fd_sc_hd__or2_1
X_431_ net65 VGND VGND VPWR VPWR _074_ sky130_fd_sc_hd__inv_2
Xclkbuf_3_6__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_6__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_629_ _250_ _251_ VGND VGND VPWR VPWR _252_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_894_ clknet_3_2__leaf_clk _035_ VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_36_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_877_ clknet_3_5__leaf_clk _018_ VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_151 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold31 net71 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 net128 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__dlygate4sd3_1
X_800_ net36 _388_ _392_ net71 _393_ VGND VGND VPWR VPWR _396_ sky130_fd_sc_hd__a221o_1
Xhold20 cnt_act\[1\] VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__dlygate4sd3_1
X_731_ net123 _343_ _099_ VGND VGND VPWR VPWR _344_ sky130_fd_sc_hd__mux2_1
X_662_ _280_ _281_ VGND VGND VPWR VPWR _282_ sky130_fd_sc_hd__xnor2_1
X_593_ net107 _219_ _166_ VGND VGND VPWR VPWR _220_ sky130_fd_sc_hd__mux2_1
X_929_ clknet_3_3__leaf_clk _070_ VGND VGND VPWR VPWR cnt_act\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xoutput76 net76 VGND VGND VPWR VPWR product[18] sky130_fd_sc_hd__clkbuf_4
Xoutput87 net87 VGND VGND VPWR VPWR product[28] sky130_fd_sc_hd__clkbuf_4
Xoutput98 net98 VGND VGND VPWR VPWR product[38] sky130_fd_sc_hd__buf_2
X_714_ _319_ _322_ _320_ VGND VGND VPWR VPWR _328_ sky130_fd_sc_hd__a21boi_1
X_645_ net114 net13 VGND VGND VPWR VPWR _266_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_26_171 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_26_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_576_ net105 _204_ _166_ VGND VGND VPWR VPWR _205_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_430_ _073_ VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_23_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_628_ net112 net10 VGND VGND VPWR VPWR _251_ sky130_fd_sc_hd__or2_1
XFILLER_0_13_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_559_ _185_ _186_ _187_ _094_ VGND VGND VPWR VPWR _189_ sky130_fd_sc_hd__a31o_1
XTAP_TAPCELL_ROW_3_90 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_893_ clknet_3_1__leaf_clk _034_ VGND VGND VPWR VPWR acu_act\[64\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_80 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_28_Left_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_876_ clknet_3_5__leaf_clk _017_ VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__dfxtp_2
XPHY_EDGE_ROW_12_Left_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_163 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xhold43 net74 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__dlygate4sd3_1
Xhold32 net85 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__dlygate4sd3_1
Xhold10 net73 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 _068_ VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__dlygate4sd3_1
X_730_ net124 _342_ _086_ VGND VGND VPWR VPWR _343_ sky130_fd_sc_hd__mux2_1
X_661_ _267_ _272_ _266_ VGND VGND VPWR VPWR _281_ sky130_fd_sc_hd__o21a_1
X_592_ net108 _218_ _087_ VGND VGND VPWR VPWR _219_ sky130_fd_sc_hd__mux2_1
XFILLER_0_21_100 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_928_ clknet_3_2__leaf_clk _069_ VGND VGND VPWR VPWR cnt_act\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_859_ clknet_3_3__leaf_clk _000_ VGND VGND VPWR VPWR estado_act\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_180 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_12_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput77 net77 VGND VGND VPWR VPWR product[19] sky130_fd_sc_hd__buf_2
Xoutput88 net88 VGND VGND VPWR VPWR product[29] sky130_fd_sc_hd__clkbuf_4
Xoutput66 net66 VGND VGND VPWR VPWR done sky130_fd_sc_hd__clkbuf_4
Xoutput99 net99 VGND VGND VPWR VPWR product[39] sky130_fd_sc_hd__clkbuf_4
X_713_ net121 net20 VGND VGND VPWR VPWR _327_ sky130_fd_sc_hd__xnor2_1
X_575_ net106 _203_ _087_ VGND VGND VPWR VPWR _204_ sky130_fd_sc_hd__mux2_1
X_644_ net114 net13 VGND VGND VPWR VPWR _265_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_15_Left_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_558_ _185_ _186_ _187_ VGND VGND VPWR VPWR _188_ sky130_fd_sc_hd__a21oi_1
X_627_ net112 net10 VGND VGND VPWR VPWR _250_ sky130_fd_sc_hd__nand2_1
X_489_ _124_ _125_ VGND VGND VPWR VPWR _126_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_0_Left_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_892_ clknet_3_1__leaf_clk _033_ VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_35_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_3_Left_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_875_ clknet_3_5__leaf_clk _016_ VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_16_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold22 net82 VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__dlygate4sd3_1
Xhold11 cnt_act\[0\] VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 net91 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 net81 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__dlygate4sd3_1
X_660_ _277_ _279_ VGND VGND VPWR VPWR _280_ sky130_fd_sc_hd__nand2_1
X_591_ _216_ _217_ VGND VGND VPWR VPWR _218_ sky130_fd_sc_hd__and2_1
X_927_ clknet_3_3__leaf_clk net151 VGND VGND VPWR VPWR cnt_act\[1\] sky130_fd_sc_hd__dfxtp_1
X_858_ _080_ _083_ _088_ _074_ net132 VGND VGND VPWR VPWR _072_ sky130_fd_sc_hd__o311a_1
X_789_ net63 _388_ _378_ net181 _379_ VGND VGND VPWR VPWR _389_ sky130_fd_sc_hd__a221o_1
XFILLER_0_16_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_54 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_29_181 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_712_ _326_ VGND VGND VPWR VPWR _028_ sky130_fd_sc_hd__clkbuf_1
Xoutput89 net89 VGND VGND VPWR VPWR product[2] sky130_fd_sc_hd__clkbuf_4
Xoutput78 net78 VGND VGND VPWR VPWR product[1] sky130_fd_sc_hd__clkbuf_4
Xoutput67 net67 VGND VGND VPWR VPWR product[0] sky130_fd_sc_hd__clkbuf_4
X_574_ _201_ _202_ VGND VGND VPWR VPWR _203_ sky130_fd_sc_hd__nor2_1
X_643_ net175 _101_ _263_ _264_ _098_ VGND VGND VPWR VPWR _021_ sky130_fd_sc_hd__o221a_1
XFILLER_0_17_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_33 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_557_ net104 net3 VGND VGND VPWR VPWR _187_ sky130_fd_sc_hd__xnor2_2
X_488_ net96 net27 VGND VGND VPWR VPWR _125_ sky130_fd_sc_hd__or2_1
X_626_ net110 _101_ _248_ _249_ _098_ VGND VGND VPWR VPWR _019_ sky130_fd_sc_hd__o221a_1
XFILLER_0_1_178 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_609_ _160_ _196_ _229_ _233_ VGND VGND VPWR VPWR _234_ sky130_fd_sc_hd__o31a_1
X_891_ clknet_3_6__leaf_clk _032_ VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_36_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_874_ clknet_3_5__leaf_clk _015_ VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__dfxtp_1
Xhold12 net89 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__dlygate4sd3_1
Xhold23 net122 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 net126 VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 net113 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__dlygate4sd3_1
X_590_ _214_ _215_ VGND VGND VPWR VPWR _217_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_113 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_788_ _372_ VGND VGND VPWR VPWR _388_ sky130_fd_sc_hd__clkbuf_4
X_926_ clknet_3_3__leaf_clk _067_ VGND VGND VPWR VPWR cnt_act\[0\] sky130_fd_sc_hd__dfxtp_1
X_857_ net131 _427_ _428_ VGND VGND VPWR VPWR _071_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_16_66 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_29_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_711_ _177_ _325_ VGND VGND VPWR VPWR _326_ sky130_fd_sc_hd__and2_1
Xoutput68 net68 VGND VGND VPWR VPWR product[10] sky130_fd_sc_hd__clkbuf_4
Xoutput79 net79 VGND VGND VPWR VPWR product[20] sky130_fd_sc_hd__clkbuf_4
X_642_ net114 _175_ _089_ VGND VGND VPWR VPWR _264_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_573_ _200_ _195_ _197_ VGND VGND VPWR VPWR _202_ sky130_fd_sc_hd__and3_1
Xclkbuf_3_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_909_ clknet_3_0__leaf_clk _050_ VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_9_109 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_7_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_625_ net112 _175_ _089_ VGND VGND VPWR VPWR _249_ sky130_fd_sc_hd__a21o_1
XFILLER_0_13_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_556_ _178_ _180_ VGND VGND VPWR VPWR _186_ sky130_fd_sc_hd__or2b_1
X_487_ net96 net27 VGND VGND VPWR VPWR _124_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_20_147 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_0_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_608_ _195_ _229_ _232_ VGND VGND VPWR VPWR _233_ sky130_fd_sc_hd__o21ba_1
X_539_ _169_ _170_ VGND VGND VPWR VPWR _171_ sky130_fd_sc_hd__nand2_1
X_890_ clknet_3_4__leaf_clk _031_ VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_873_ clknet_3_5__leaf_clk _014_ VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_1_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold24 net88 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 net70 VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__dlygate4sd3_1
Xhold13 cnt_act\[3\] VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__dlygate4sd3_1
Xhold46 net104 VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__dlygate4sd3_1
X_925_ clknet_3_2__leaf_clk _066_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_125 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_787_ net172 _000_ _387_ VGND VGND VPWR VPWR _042_ sky130_fd_sc_hd__o21a_1
X_856_ net131 _427_ _074_ VGND VGND VPWR VPWR _428_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_16_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_158 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput69 net69 VGND VGND VPWR VPWR product[11] sky130_fd_sc_hd__clkbuf_4
X_710_ net120 _324_ _166_ VGND VGND VPWR VPWR _325_ sky130_fd_sc_hd__mux2_1
X_572_ _195_ _197_ _200_ VGND VGND VPWR VPWR _201_ sky130_fd_sc_hd__a21oi_1
X_641_ _260_ _261_ _262_ VGND VGND VPWR VPWR _263_ sky130_fd_sc_hd__a21oi_1
X_908_ clknet_3_0__leaf_clk net156 VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dfxtp_1
X_839_ net154 _078_ _417_ VGND VGND VPWR VPWR _064_ sky130_fd_sc_hd__o21a_1
XFILLER_0_27_99 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_32_189 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_555_ net103 net2 VGND VGND VPWR VPWR _185_ sky130_fd_sc_hd__nand2_1
X_624_ _095_ _247_ VGND VGND VPWR VPWR _248_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_486_ net95 _101_ _102_ _123_ VGND VGND VPWR VPWR _005_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_19_Left_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_20_148 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_24_12 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_538_ net102 net32 VGND VGND VPWR VPWR _170_ sky130_fd_sc_hd__or2_1
X_607_ net108 net7 _228_ _230_ _231_ VGND VGND VPWR VPWR _232_ sky130_fd_sc_hd__a221o_1
X_469_ net93 _101_ _102_ _108_ VGND VGND VPWR VPWR _003_ sky130_fd_sc_hd__o211a_1
XFILLER_0_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_872_ clknet_3_4__leaf_clk _013_ VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_21_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_1_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xhold25 net72 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 net67 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__dlygate4sd3_1
Xhold14 net84 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 net99 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_7_Left_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_137 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_924_ clknet_3_2__leaf_clk _065_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dfxtp_1
X_786_ net62 _373_ _378_ net135 _379_ VGND VGND VPWR VPWR _387_ sky130_fd_sc_hd__a221o_1
X_855_ net65 _426_ _427_ VGND VGND VPWR VPWR _070_ sky130_fd_sc_hd__nor3_1
XFILLER_0_8_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_571_ _198_ _199_ VGND VGND VPWR VPWR _200_ sky130_fd_sc_hd__nand2_1
X_640_ _260_ _261_ _088_ VGND VGND VPWR VPWR _262_ sky130_fd_sc_hd__o21ai_1
X_838_ net54 _372_ _406_ net90 _407_ VGND VGND VPWR VPWR _417_ sky130_fd_sc_hd__a221o_1
X_907_ clknet_3_1__leaf_clk _048_ VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_769_ _372_ _087_ VGND VGND VPWR VPWR _377_ sky130_fd_sc_hd__nor2_1
XFILLER_0_7_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_554_ _184_ VGND VGND VPWR VPWR _012_ sky130_fd_sc_hd__clkbuf_1
X_485_ net96 _094_ _120_ _122_ _089_ VGND VGND VPWR VPWR _123_ sky130_fd_sc_hd__a221o_1
X_623_ _245_ _246_ VGND VGND VPWR VPWR _247_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_20_149 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_11_116 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_36_Left_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_20_Left_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_468_ net94 _095_ _107_ _080_ VGND VGND VPWR VPWR _108_ sky130_fd_sc_hd__a211o_1
XFILLER_0_24_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_537_ net102 net32 VGND VGND VPWR VPWR _169_ sky130_fd_sc_hd__nand2_1
X_606_ net108 net7 net6 net107 VGND VGND VPWR VPWR _231_ sky130_fd_sc_hd__o211a_1
XFILLER_0_4_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_10_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_0_74 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xclkbuf_3_7__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_7__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_871_ clknet_3_4__leaf_clk _012_ VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_21_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_23_Left_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold37 net76 VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 _049_ VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__dlygate4sd3_1
Xhold15 net87 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__dlygate4sd3_1
Xhold48 net119 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__dlygate4sd3_1
X_923_ clknet_3_2__leaf_clk _064_ VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dfxtp_1
X_854_ cnt_act\[3\] cnt_act\[2\] cnt_act\[1\] _422_ VGND VGND VPWR VPWR _427_ sky130_fd_sc_hd__and4_1
X_785_ net171 _000_ _386_ VGND VGND VPWR VPWR _041_ sky130_fd_sc_hd__o21a_1
XFILLER_0_7_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_570_ net105 net4 VGND VGND VPWR VPWR _199_ sky130_fd_sc_hd__nand2_1
X_906_ clknet_3_1__leaf_clk _047_ VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dfxtp_1
X_837_ net145 _404_ _416_ VGND VGND VPWR VPWR _063_ sky130_fd_sc_hd__o21a_1
X_768_ _374_ _376_ _373_ VGND VGND VPWR VPWR _034_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_27_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_68 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_699_ _304_ _307_ _305_ VGND VGND VPWR VPWR _315_ sky130_fd_sc_hd__a21oi_1
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_4_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_23_158 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_31_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_622_ _234_ _237_ _236_ VGND VGND VPWR VPWR _246_ sky130_fd_sc_hd__o21a_1
X_553_ _177_ _183_ VGND VGND VPWR VPWR _184_ sky130_fd_sc_hd__and2_1
X_484_ _094_ _121_ VGND VGND VPWR VPWR _122_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_11_117 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_605_ _199_ _208_ _207_ VGND VGND VPWR VPWR _230_ sky130_fd_sc_hd__a21oi_1
X_467_ _091_ _105_ _106_ VGND VGND VPWR VPWR _107_ sky130_fd_sc_hd__o21a_1
X_536_ _168_ VGND VGND VPWR VPWR _010_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_75 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_25 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_27_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_519_ _095_ _152_ VGND VGND VPWR VPWR _153_ sky130_fd_sc_hd__nor2_1
XFILLER_0_2_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_870_ clknet_3_4__leaf_clk _011_ VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_24_114 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_15_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_30_128 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xhold38 _053_ VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__dlygate4sd3_1
Xhold16 net78 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__dlygate4sd3_1
Xhold27 net130 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__dlygate4sd3_1
Xhold49 net79 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__dlygate4sd3_1
X_922_ clknet_3_2__leaf_clk _063_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__dfxtp_1
X_784_ net61 _373_ _378_ net128 _379_ VGND VGND VPWR VPWR _386_ sky130_fd_sc_hd__a221o_1
X_853_ cnt_act\[2\] cnt_act\[1\] _422_ net143 VGND VGND VPWR VPWR _426_ sky130_fd_sc_hd__a31oi_1
XFILLER_0_12_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_26_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_905_ clknet_3_1__leaf_clk _046_ VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dfxtp_1
X_836_ net53 _372_ _406_ net88 _407_ VGND VGND VPWR VPWR _416_ sky130_fd_sc_hd__a221o_1
X_767_ _365_ _375_ _095_ VGND VGND VPWR VPWR _376_ sky130_fd_sc_hd__a21o_1
X_698_ _312_ _313_ VGND VGND VPWR VPWR _314_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_4_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_23_159 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_621_ _242_ _244_ VGND VGND VPWR VPWR _245_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_14_126 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_552_ net103 _182_ _166_ VGND VGND VPWR VPWR _183_ sky130_fd_sc_hd__mux2_1
X_483_ _118_ _119_ _113_ _115_ VGND VGND VPWR VPWR _121_ sky130_fd_sc_hd__o211a_1
X_819_ _077_ VGND VGND VPWR VPWR _407_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_9_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_11_118 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_535_ _102_ _167_ VGND VGND VPWR VPWR _168_ sky130_fd_sc_hd__and2_1
X_604_ _200_ _209_ _228_ VGND VGND VPWR VPWR _229_ sky130_fd_sc_hd__or3b_1
XFILLER_0_6_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_466_ _091_ _105_ _094_ VGND VGND VPWR VPWR _106_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_4_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_0_76 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_19_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_518_ _149_ _151_ VGND VGND VPWR VPWR _152_ sky130_fd_sc_hd__xnor2_1
X_449_ net93 net92 _089_ VGND VGND VPWR VPWR _090_ sky130_fd_sc_hd__mux2_1
XFILLER_0_18_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold39 net86 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__dlygate4sd3_1
Xhold28 net80 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__dlygate4sd3_1
Xhold17 net79 VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_36_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_921_ clknet_3_0__leaf_clk net170 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dfxtp_1
X_852_ net160 _425_ VGND VGND VPWR VPWR _069_ sky130_fd_sc_hd__nor2_1
X_783_ net153 _000_ _385_ VGND VGND VPWR VPWR _040_ sky130_fd_sc_hd__o21a_1
XFILLER_0_16_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_16_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_32_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_20_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_26_168 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_904_ clknet_3_0__leaf_clk _045_ VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dfxtp_1
X_835_ net169 _404_ _415_ VGND VGND VPWR VPWR _062_ sky130_fd_sc_hd__o21a_1
X_697_ net119 net18 VGND VGND VPWR VPWR _313_ sky130_fd_sc_hd__or2_1
X_766_ _353_ _363_ _364_ VGND VGND VPWR VPWR _375_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_4_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_551_ net104 _181_ _087_ VGND VGND VPWR VPWR _182_ sky130_fd_sc_hd__mux2_1
X_620_ _243_ VGND VGND VPWR VPWR _244_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_14_127 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_482_ _113_ _115_ _118_ _119_ VGND VGND VPWR VPWR _120_ sky130_fd_sc_hd__a211o_1
XFILLER_0_22_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_818_ _377_ VGND VGND VPWR VPWR _406_ sky130_fd_sc_hd__clkbuf_4
X_749_ net125 _359_ _099_ VGND VGND VPWR VPWR _360_ sky130_fd_sc_hd__mux2_1
X_465_ _103_ _104_ VGND VGND VPWR VPWR _105_ sky130_fd_sc_hd__nand2_1
X_534_ net101 _165_ _166_ VGND VGND VPWR VPWR _167_ sky130_fd_sc_hd__mux2_1
X_603_ _214_ _223_ VGND VGND VPWR VPWR _228_ sky130_fd_sc_hd__nor2_1
XFILLER_0_36_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_0_77 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_19_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_448_ _079_ VGND VGND VPWR VPWR _089_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_517_ net98 net29 _150_ VGND VGND VPWR VPWR _151_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_18_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_27 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xhold18 net83 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__dlygate4sd3_1
Xhold29 cnt_act\[2\] VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__dlygate4sd3_1
X_920_ clknet_3_0__leaf_clk _061_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dfxtp_1
X_851_ cnt_act\[2\] cnt_act\[1\] _422_ net65 VGND VGND VPWR VPWR _425_ sky130_fd_sc_hd__a31o_1
X_782_ net60 _373_ _378_ net127 _379_ VGND VGND VPWR VPWR _385_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_6_98 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_20_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_27_Left_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_11_Left_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_26_169 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_834_ net52 _402_ _406_ net87 _407_ VGND VGND VPWR VPWR _415_ sky130_fd_sc_hd__a221o_1
X_903_ clknet_3_1__leaf_clk _044_ VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__dfxtp_1
X_696_ net119 net18 VGND VGND VPWR VPWR _312_ sky130_fd_sc_hd__nand2_1
X_765_ net133 _080_ VGND VGND VPWR VPWR _374_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_481_ net95 net26 VGND VGND VPWR VPWR _119_ sky130_fd_sc_hd__and2_1
X_550_ _178_ _180_ VGND VGND VPWR VPWR _181_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_14_128 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_88 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_817_ net137 _404_ _405_ VGND VGND VPWR VPWR _054_ sky130_fd_sc_hd__o21a_1
X_748_ net126 _358_ _086_ VGND VGND VPWR VPWR _359_ sky130_fd_sc_hd__mux2_1
X_679_ _295_ _296_ _088_ VGND VGND VPWR VPWR _297_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_14_Left_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_602_ net108 _101_ _226_ _227_ _098_ VGND VGND VPWR VPWR _017_ sky130_fd_sc_hd__o221a_1
X_533_ _099_ VGND VGND VPWR VPWR _166_ sky130_fd_sc_hd__buf_4
X_464_ net93 net12 VGND VGND VPWR VPWR _104_ sky130_fd_sc_hd__or2_1
Xclkbuf_3_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_5_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_78 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_35_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_516_ _142_ _144_ VGND VGND VPWR VPWR _150_ sky130_fd_sc_hd__or2b_1
X_447_ _087_ VGND VGND VPWR VPWR _088_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_24_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_1_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_39 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_172 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_30_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold19 net90 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_14_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_781_ net138 _000_ _384_ VGND VGND VPWR VPWR _039_ sky130_fd_sc_hd__o21a_1
X_850_ cnt_act\[1\] _422_ net159 VGND VGND VPWR VPWR _424_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_6_99 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_109 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_20_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_902_ clknet_3_0__leaf_clk _043_ VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__dfxtp_1
X_833_ net162 _404_ _414_ VGND VGND VPWR VPWR _061_ sky130_fd_sc_hd__o21a_1
X_764_ _362_ _370_ _373_ VGND VGND VPWR VPWR _033_ sky130_fd_sc_hd__a21oi_1
X_695_ _311_ VGND VGND VPWR VPWR _026_ sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_17_137 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_8_105 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_480_ net95 net26 VGND VGND VPWR VPWR _118_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_14_129 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_3_89 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_816_ net43 _402_ _392_ net179 _393_ VGND VGND VPWR VPWR _405_ sky130_fd_sc_hd__a221o_1
X_747_ _355_ _357_ VGND VGND VPWR VPWR _358_ sky130_fd_sc_hd__xor2_1
X_678_ _286_ _288_ _285_ VGND VGND VPWR VPWR _296_ sky130_fd_sc_hd__a21boi_1
X_601_ net109 _175_ _089_ VGND VGND VPWR VPWR _227_ sky130_fd_sc_hd__a21o_1
X_463_ net93 net12 VGND VGND VPWR VPWR _103_ sky130_fd_sc_hd__nand2_1
X_532_ net102 _164_ _087_ VGND VGND VPWR VPWR _165_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_0_79 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_515_ net99 net30 VGND VGND VPWR VPWR _149_ sky130_fd_sc_hd__xor2_1
X_446_ _086_ VGND VGND VPWR VPWR _087_ sky130_fd_sc_hd__buf_4
X_429_ estado_act\[1\] estado_act\[0\] VGND VGND VPWR VPWR _073_ sky130_fd_sc_hd__and2_1
XFILLER_0_23_184 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput1 mcand[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__buf_1
X_780_ net59 _373_ _378_ net122 _379_ VGND VGND VPWR VPWR _384_ sky130_fd_sc_hd__a221o_1
XTAP_TAPCELL_ROW_29_179 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_901_ clknet_3_0__leaf_clk _042_ VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__dfxtp_1
X_763_ _372_ VGND VGND VPWR VPWR _373_ sky130_fd_sc_hd__clkbuf_4
X_832_ net51 _402_ _406_ net86 _407_ VGND VGND VPWR VPWR _414_ sky130_fd_sc_hd__a221o_1
X_694_ _177_ _310_ VGND VGND VPWR VPWR _311_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_17_138 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_16_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_8_106 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_815_ _078_ VGND VGND VPWR VPWR _404_ sky130_fd_sc_hd__clkbuf_4
X_746_ _338_ _341_ _348_ _356_ VGND VGND VPWR VPWR _357_ sky130_fd_sc_hd__o31a_1
X_677_ _293_ _294_ VGND VGND VPWR VPWR _295_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_531_ _160_ _163_ VGND VGND VPWR VPWR _164_ sky130_fd_sc_hd__xor2_1
X_600_ _224_ _225_ VGND VGND VPWR VPWR _226_ sky130_fd_sc_hd__nor2_1
X_462_ _097_ VGND VGND VPWR VPWR _102_ sky130_fd_sc_hd__clkbuf_4
X_729_ _338_ _341_ VGND VGND VPWR VPWR _342_ sky130_fd_sc_hd__xor2_1
XFILLER_0_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_30_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_514_ _148_ VGND VGND VPWR VPWR _008_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_445_ _085_ VGND VGND VPWR VPWR _086_ sky130_fd_sc_hd__buf_2
XFILLER_0_35_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_196 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput2 mcand[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_36_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_831_ net144 _404_ _413_ VGND VGND VPWR VPWR _060_ sky130_fd_sc_hd__o21a_1
X_900_ clknet_3_1__leaf_clk _041_ VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__dfxtp_1
X_762_ _371_ VGND VGND VPWR VPWR _372_ sky130_fd_sc_hd__clkbuf_2
X_693_ net118 _309_ _166_ VGND VGND VPWR VPWR _310_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_17_139 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_119 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_31_186 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput60 mplier[5] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_8_107 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_814_ net167 _390_ _403_ VGND VGND VPWR VPWR _053_ sky130_fd_sc_hd__o21a_1
X_745_ _340_ _347_ _346_ VGND VGND VPWR VPWR _356_ sky130_fd_sc_hd__a21bo_1
X_676_ net117 net16 VGND VGND VPWR VPWR _294_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_21_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_461_ _100_ VGND VGND VPWR VPWR _101_ sky130_fd_sc_hd__clkbuf_4
X_530_ _161_ _162_ VGND VGND VPWR VPWR _163_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_10_112 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_728_ _339_ _340_ VGND VGND VPWR VPWR _341_ sky130_fd_sc_hd__nand2_1
X_659_ _278_ VGND VGND VPWR VPWR _279_ sky130_fd_sc_hd__inv_2
XFILLER_0_30_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_18_Left_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_180 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_36_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_444_ estado_act\[1\] estado_act\[0\] net67 VGND VGND VPWR VPWR _085_ sky130_fd_sc_hd__and3b_1
X_513_ _102_ _147_ VGND VGND VPWR VPWR _148_ sky130_fd_sc_hd__and2_1
XFILLER_0_27_117 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_26_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_17_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_120 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_153 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_32_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_23_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput3 mcand[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__dlymetal6s2s_1
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_123 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_7_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_830_ net50 _402_ _406_ net85 _407_ VGND VGND VPWR VPWR _413_ sky130_fd_sc_hd__a221o_1
X_761_ net65 _075_ VGND VGND VPWR VPWR _371_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_6_Left_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_692_ net119 _308_ _086_ VGND VGND VPWR VPWR _309_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput61 mplier[6] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_1
Xinput50 mplier[25] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_31_187 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_8_108 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_22_154 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_32_Left_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_813_ net42 _402_ _392_ net77 _393_ VGND VGND VPWR VPWR _403_ sky130_fd_sc_hd__a221o_1
X_744_ _353_ _354_ VGND VGND VPWR VPWR _355_ sky130_fd_sc_hd__nand2_1
X_675_ net117 net16 VGND VGND VPWR VPWR _293_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_5_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_460_ _099_ VGND VGND VPWR VPWR _100_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_10_113 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_727_ net123 net21 VGND VGND VPWR VPWR _340_ sky130_fd_sc_hd__nand2_1
XFILLER_0_14_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_658_ net115 net14 VGND VGND VPWR VPWR _278_ sky130_fd_sc_hd__nor2_1
X_589_ _214_ _215_ VGND VGND VPWR VPWR _216_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_4_91 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_97 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_443_ _080_ _084_ VGND VGND VPWR VPWR _001_ sky130_fd_sc_hd__nor2_1
X_512_ net98 _146_ _100_ VGND VGND VPWR VPWR _147_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_129 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_35_Left_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_165 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_1_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_11_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_99 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_1_81 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput4 mcand[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_1
XFILLER_0_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_20_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_202 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_34_196 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_760_ _367_ _368_ _369_ VGND VGND VPWR VPWR _370_ sky130_fd_sc_hd__o21ai_1
X_691_ _304_ _307_ VGND VGND VPWR VPWR _308_ sky130_fd_sc_hd__xor2_1
XFILLER_0_17_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_889_ clknet_3_6__leaf_clk _030_ VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_3_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput40 mplier[16] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_31_188 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput51 mplier[26] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__buf_1
Xinput62 mplier[7] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__dlymetal6s2s_1
XTAP_TAPCELL_ROW_22_155 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_812_ _372_ VGND VGND VPWR VPWR _402_ sky130_fd_sc_hd__clkbuf_4
X_743_ net125 net24 VGND VGND VPWR VPWR _354_ sky130_fd_sc_hd__or2_1
X_674_ _292_ VGND VGND VPWR VPWR _024_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_203 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_10_114 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_726_ net123 net21 VGND VGND VPWR VPWR _339_ sky130_fd_sc_hd__or2_1
X_657_ net115 net14 VGND VGND VPWR VPWR _277_ sky130_fd_sc_hd__nand2_1
XFILLER_0_14_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_588_ _208_ _210_ _207_ VGND VGND VPWR VPWR _215_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_4_92 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_511_ net99 _145_ _087_ VGND VGND VPWR VPWR _146_ sky130_fd_sc_hd__mux2_1
X_442_ estado_act\[1\] _081_ _083_ net132 VGND VGND VPWR VPWR _084_ sky130_fd_sc_hd__o22a_1
XFILLER_0_35_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_709_ net121 _323_ _086_ VGND VGND VPWR VPWR _324_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_32_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_1_82 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput5 mcand[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__buf_1
XFILLER_0_36_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_34_197 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_690_ _305_ _306_ VGND VGND VPWR VPWR _307_ sky130_fd_sc_hd__nor2_1
X_888_ clknet_3_6__leaf_clk _029_ VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__dfxtp_2
Xinput63 mplier[8] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__buf_1
Xinput52 mplier[27] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_1
Xinput30 mcand[7] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__buf_1
Xinput41 mplier[17] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__buf_1
XFILLER_0_35_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_22_156 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_811_ net136 _390_ _401_ VGND VGND VPWR VPWR _052_ sky130_fd_sc_hd__o21a_1
X_742_ net125 net24 VGND VGND VPWR VPWR _353_ sky130_fd_sc_hd__nand2_1
X_673_ _177_ _291_ VGND VGND VPWR VPWR _292_ sky130_fd_sc_hd__and2_1
XTAP_TAPCELL_ROW_13_123 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_36_204 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_10_115 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_725_ _304_ _333_ _337_ VGND VGND VPWR VPWR _338_ sky130_fd_sc_hd__a21oi_1
X_656_ _276_ VGND VGND VPWR VPWR _022_ sky130_fd_sc_hd__clkbuf_1
X_587_ net107 net6 VGND VGND VPWR VPWR _214_ sky130_fd_sc_hd__xnor2_1
XTAP_TAPCELL_ROW_4_93 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_441_ cnt_act\[2\] cnt_act\[1\] _082_ VGND VGND VPWR VPWR _083_ sky130_fd_sc_hd__nand3_1
X_510_ _142_ _144_ VGND VGND VPWR VPWR _145_ sky130_fd_sc_hd__xnor2_1
X_708_ _321_ _322_ VGND VGND VPWR VPWR _323_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_25_77 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_639_ _251_ _253_ _250_ VGND VGND VPWR VPWR _261_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_26_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_1_83 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput6 mcand[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_36_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_14_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_14_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_3_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_34_198 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_6_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_25_165 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_887_ clknet_3_0__leaf_clk _028_ VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__dfxtp_1
Xinput31 mcand[8] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_33_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput20 mcand[27] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput42 mplier[18] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__buf_1
Xinput64 mplier[9] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__buf_1
Xinput53 mplier[28] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_22_157 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_810_ net41 _388_ _392_ net76 _393_ VGND VGND VPWR VPWR _401_ sky130_fd_sc_hd__a221o_1
X_741_ net124 _100_ _351_ _352_ _102_ VGND VGND VPWR VPWR _031_ sky130_fd_sc_hd__o221a_1
X_672_ net116 _290_ _166_ VGND VGND VPWR VPWR _291_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_13_124 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_14_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_36_205 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_724_ _313_ _332_ _334_ _336_ VGND VGND VPWR VPWR _337_ sky130_fd_sc_hd__a31o_1
XFILLER_0_14_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_655_ _177_ _275_ VGND VGND VPWR VPWR _276_ sky130_fd_sc_hd__and2_1
X_586_ net106 _101_ _212_ _213_ _098_ VGND VGND VPWR VPWR _015_ sky130_fd_sc_hd__o221a_1
XTAP_TAPCELL_ROW_4_94 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_30_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_440_ cnt_act\[4\] cnt_act\[3\] cnt_act\[0\] VGND VGND VPWR VPWR _082_ sky130_fd_sc_hd__and3_1
XFILLER_0_35_154 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_707_ _312_ _315_ _313_ VGND VGND VPWR VPWR _322_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_25_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_569_ net105 net4 VGND VGND VPWR VPWR _198_ sky130_fd_sc_hd__or2_1
XFILLER_0_26_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_638_ _258_ _259_ VGND VGND VPWR VPWR _260_ sky130_fd_sc_hd__or2b_1
XFILLER_0_5_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput7 mcand[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_1
XFILLER_0_36_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_34_199 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput130 net130 VGND VGND VPWR VPWR product[9] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_25_166 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_886_ clknet_3_1__leaf_clk _027_ VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_16_133 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput10 mcand[18] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_1
Xinput43 mplier[19] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_1
Xinput21 mcand[28] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_26_Left_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput32 mcand[9] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput54 mplier[29] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__buf_1
XFILLER_0_3_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_10_Left_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput65 st VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_30_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_740_ net125 _094_ _089_ VGND VGND VPWR VPWR _352_ sky130_fd_sc_hd__a21o_1
X_671_ net117 _289_ _086_ VGND VGND VPWR VPWR _290_ sky130_fd_sc_hd__mux2_1
XTAP_TAPCELL_ROW_13_125 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_869_ clknet_3_5__leaf_clk _010_ VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_36_206 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_723_ net121 net20 _335_ VGND VGND VPWR VPWR _336_ sky130_fd_sc_hd__a21o_1
X_654_ net114 _274_ _166_ VGND VGND VPWR VPWR _275_ sky130_fd_sc_hd__mux2_1
X_585_ net107 _175_ _080_ VGND VGND VPWR VPWR _213_ sky130_fd_sc_hd__a21o_1
XFILLER_0_12_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_13_Left_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_706_ _319_ _320_ VGND VGND VPWR VPWR _321_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_637_ net113 net11 VGND VGND VPWR VPWR _259_ sky130_fd_sc_hd__nand2_1
X_568_ _160_ _196_ VGND VGND VPWR VPWR _197_ sky130_fd_sc_hd__or2_1
X_499_ net97 net28 VGND VGND VPWR VPWR _135_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput8 mcand[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__buf_1
XFILLER_0_20_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_175 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_2_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput120 net120 VGND VGND VPWR VPWR product[58] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_25_167 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_885_ clknet_3_1__leaf_clk _026_ VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_17_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_16_134 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput33 mplier[0] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_169 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput55 mplier[2] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_1
Xinput11 mcand[19] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_1
Xinput22 mcand[29] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__buf_1
Xinput44 mplier[1] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_7_102 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_670_ _287_ _288_ VGND VGND VPWR VPWR _289_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_799_ net134 _390_ _395_ VGND VGND VPWR VPWR _046_ sky130_fd_sc_hd__o21a_1
XFILLER_0_28_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_868_ clknet_3_7__leaf_clk _009_ VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dfxtp_2
XTAP_TAPCELL_ROW_36_207 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_722_ net121 net20 net19 net120 VGND VGND VPWR VPWR _335_ sky130_fd_sc_hd__o211a_1
X_653_ net115 _273_ _086_ VGND VGND VPWR VPWR _274_ sky130_fd_sc_hd__mux2_1
X_584_ _209_ _210_ _211_ VGND VGND VPWR VPWR _212_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_30_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_705_ net120 net19 VGND VGND VPWR VPWR _320_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_567_ _163_ _171_ _178_ _187_ VGND VGND VPWR VPWR _196_ sky130_fd_sc_hd__or4_1
X_636_ net113 net11 VGND VGND VPWR VPWR _258_ sky130_fd_sc_hd__nor2_1
XFILLER_0_26_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_498_ _134_ VGND VGND VPWR VPWR _006_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_11_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput9 mcand[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_1
XFILLER_0_36_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_619_ net110 net9 VGND VGND VPWR VPWR _243_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_107 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_28_176 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_22_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput121 net121 VGND VGND VPWR VPWR product[59] sky130_fd_sc_hd__clkbuf_4
Xoutput110 net110 VGND VGND VPWR VPWR product[49] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_884_ clknet_3_4__leaf_clk _025_ VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_16_135 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput45 mplier[20] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_1
Xinput23 mcand[2] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__buf_1
Xinput12 mcand[1] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_1
Xinput34 mplier[10] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__buf_1
Xinput56 mplier[30] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__buf_1
XFILLER_0_28_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_7_103 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_30_182 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_36_208 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_798_ net35 _388_ _392_ net70 _393_ VGND VGND VPWR VPWR _395_ sky130_fd_sc_hd__a221o_1
X_867_ clknet_3_7__leaf_clk _008_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_12_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_18_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_721_ _305_ _312_ VGND VGND VPWR VPWR _334_ sky130_fd_sc_hd__or2b_1
X_652_ _267_ _272_ VGND VGND VPWR VPWR _273_ sky130_fd_sc_hd__xor2_1
X_583_ _209_ _210_ _088_ VGND VGND VPWR VPWR _211_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_30_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_919_ clknet_3_0__leaf_clk _060_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dfxtp_1
Xhold1 cnt_act\[4\] VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_704_ net120 net19 VGND VGND VPWR VPWR _319_ sky130_fd_sc_hd__or2_1
X_566_ _185_ _192_ _193_ _194_ VGND VGND VPWR VPWR _195_ sky130_fd_sc_hd__o211a_1
X_635_ _257_ VGND VGND VPWR VPWR _020_ sky130_fd_sc_hd__clkbuf_1
X_497_ _102_ _133_ VGND VGND VPWR VPWR _134_ sky130_fd_sc_hd__and2_1
X_549_ _169_ _172_ _179_ VGND VGND VPWR VPWR _180_ sky130_fd_sc_hd__a21oi_1
X_618_ net110 net9 VGND VGND VPWR VPWR _242_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_28_177 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_144 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput111 net111 VGND VGND VPWR VPWR product[4] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xoutput122 net122 VGND VGND VPWR VPWR product[5] sky130_fd_sc_hd__buf_2
Xoutput100 net100 VGND VGND VPWR VPWR product[3] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_33_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_883_ clknet_3_5__leaf_clk _024_ VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__dfxtp_2
XTAP_TAPCELL_ROW_16_136 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput13 mcand[20] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_1
XFILLER_0_3_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
Xinput24 mcand[30] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__buf_1
Xinput57 mplier[31] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_1
Xinput35 mplier[11] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__buf_1
Xinput46 mplier[21] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_30_183 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_7_104 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_28_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_866_ clknet_3_7__leaf_clk _007_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_36_209 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_797_ net139 _390_ _394_ VGND VGND VPWR VPWR _045_ sky130_fd_sc_hd__o21a_1
X_720_ _307_ _312_ _313_ _332_ VGND VGND VPWR VPWR _333_ sky130_fd_sc_hd__and4_1
X_582_ net105 net4 _201_ VGND VGND VPWR VPWR _210_ sky130_fd_sc_hd__a21oi_1
X_651_ _234_ _268_ _269_ _271_ VGND VGND VPWR VPWR _272_ sky130_fd_sc_hd__o31a_1
X_918_ clknet_3_0__leaf_clk _059_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dfxtp_1
X_849_ net150 _422_ _423_ VGND VGND VPWR VPWR _068_ sky130_fd_sc_hd__a21oi_1
Xhold2 cnt_act\[5\] VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_29_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_703_ net178 _100_ _317_ _318_ _102_ VGND VGND VPWR VPWR _027_ sky130_fd_sc_hd__o221a_1
X_634_ _177_ _256_ VGND VGND VPWR VPWR _257_ sky130_fd_sc_hd__and2_1
XFILLER_0_25_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_565_ _162_ _169_ _179_ _178_ _187_ VGND VGND VPWR VPWR _194_ sky130_fd_sc_hd__a2111o_1
X_496_ net96 _132_ _100_ VGND VGND VPWR VPWR _133_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_180 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_10_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_17_Left_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_617_ _241_ VGND VGND VPWR VPWR _018_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_479_ _088_ _109_ _117_ _098_ VGND VGND VPWR VPWR _004_ sky130_fd_sc_hd__o211a_1
X_548_ net102 net32 VGND VGND VPWR VPWR _179_ sky130_fd_sc_hd__nor2_1
XFILLER_0_26_70 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_2_Left_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_28_178 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_19_145 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_12_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput112 net112 VGND VGND VPWR VPWR product[50] sky130_fd_sc_hd__clkbuf_4
Xoutput123 net123 VGND VGND VPWR VPWR product[60] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput101 net101 VGND VGND VPWR VPWR product[40] sky130_fd_sc_hd__clkbuf_4
X_882_ clknet_3_7__leaf_clk _023_ VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_33_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput14 mcand[21] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__buf_1
Xinput36 mplier[12] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_1
Xinput25 mcand[31] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__buf_1
Xinput58 mplier[3] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_1
Xinput47 mplier[22] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_1
XTAP_TAPCELL_ROW_30_184 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_3_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_151 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_5_Left_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_796_ net34 _388_ _392_ net134 _393_ VGND VGND VPWR VPWR _394_ sky130_fd_sc_hd__a221o_1
X_865_ clknet_3_7__leaf_clk _006_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dfxtp_2
XFILLER_0_28_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_18_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_33_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_31_Left_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_650_ _250_ _258_ _269_ _270_ _259_ VGND VGND VPWR VPWR _271_ sky130_fd_sc_hd__o221a_1
X_581_ _207_ _208_ VGND VGND VPWR VPWR _209_ sky130_fd_sc_hd__or2b_1
X_779_ net100 _000_ _383_ VGND VGND VPWR VPWR _038_ sky130_fd_sc_hd__o21a_1
X_917_ clknet_3_2__leaf_clk _058_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dfxtp_1
X_848_ cnt_act\[1\] _422_ _074_ VGND VGND VPWR VPWR _423_ sky130_fd_sc_hd__o21ai_1
Xhold3 acu_act\[64\] VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_29_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_0_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_702_ net120 _175_ _089_ VGND VGND VPWR VPWR _318_ sky130_fd_sc_hd__a21o_1
X_633_ net112 _255_ _166_ VGND VGND VPWR VPWR _256_ sky130_fd_sc_hd__mux2_1
X_564_ net104 net3 VGND VGND VPWR VPWR _193_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_495_ _130_ _131_ net97 _094_ VGND VGND VPWR VPWR _132_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_34_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_72 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_17_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_547_ net103 net2 VGND VGND VPWR VPWR _178_ sky130_fd_sc_hd__xnor2_2
X_616_ _177_ _240_ VGND VGND VPWR VPWR _241_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_34_Left_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_478_ _115_ _116_ _095_ VGND VGND VPWR VPWR _117_ sky130_fd_sc_hd__a21o_1
XFILLER_0_22_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_13_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_2_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_19_146 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput124 net124 VGND VGND VPWR VPWR product[61] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput102 net102 VGND VGND VPWR VPWR product[41] sky130_fd_sc_hd__clkbuf_4
Xoutput113 net113 VGND VGND VPWR VPWR product[51] sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_33_193 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_17_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_881_ clknet_3_6__leaf_clk _022_ VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__dfxtp_1
Xinput26 mcand[3] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_1
Xinput15 mcand[22] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__buf_1
XFILLER_0_24_202 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xinput48 mplier[23] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__buf_1
Xinput37 mplier[13] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_1
Xinput59 mplier[4] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_30_185 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_152 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_795_ _077_ VGND VGND VPWR VPWR _393_ sky130_fd_sc_hd__clkbuf_4
X_864_ clknet_3_6__leaf_clk _005_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dfxtp_1
Xclkbuf_3_4__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_4__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_26_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_35_200 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_580_ net106 net5 VGND VGND VPWR VPWR _208_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_29 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_916_ clknet_3_2__leaf_clk _057_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dfxtp_1
Xhold4 net69 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__dlygate4sd3_1
X_778_ net58 _373_ _378_ net180 _379_ VGND VGND VPWR VPWR _383_ sky130_fd_sc_hd__a221o_1
X_847_ net65 _420_ _422_ VGND VGND VPWR VPWR _067_ sky130_fd_sc_hd__nor3_1
XFILLER_0_4_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_35_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_701_ _314_ _315_ _316_ VGND VGND VPWR VPWR _317_ sky130_fd_sc_hd__a21oi_1
X_563_ net104 net3 VGND VGND VPWR VPWR _192_ sky130_fd_sc_hd__nor2_1
X_632_ net113 _254_ _087_ VGND VGND VPWR VPWR _255_ sky130_fd_sc_hd__mux2_1
X_494_ _126_ _129_ _093_ VGND VGND VPWR VPWR _131_ sky130_fd_sc_hd__a21o_1
XFILLER_0_26_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_546_ _097_ VGND VGND VPWR VPWR _177_ sky130_fd_sc_hd__clkbuf_4
X_615_ net109 _239_ _166_ VGND VGND VPWR VPWR _240_ sky130_fd_sc_hd__mux2_1
X_477_ _111_ _114_ VGND VGND VPWR VPWR _116_ sky130_fd_sc_hd__or2_1
XFILLER_0_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_93 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_529_ net101 net31 VGND VGND VPWR VPWR _162_ sky130_fd_sc_hd__nand2_1
Xoutput125 net125 VGND VGND VPWR VPWR product[62] sky130_fd_sc_hd__clkbuf_4
Xoutput103 net103 VGND VGND VPWR VPWR product[42] sky130_fd_sc_hd__clkbuf_4
Xoutput114 net114 VGND VGND VPWR VPWR product[52] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_12_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XTAP_TAPCELL_ROW_33_194 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_880_ clknet_3_7__leaf_clk _021_ VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_24_161 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput16 mcand[23] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__buf_1
XFILLER_0_24_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xinput49 mplier[24] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__buf_1
Xinput27 mcand[4] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__buf_1
Xinput38 mplier[14] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_3_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_21_153 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_863_ clknet_3_7__leaf_clk _004_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dfxtp_2
X_794_ _377_ VGND VGND VPWR VPWR _392_ sky130_fd_sc_hd__clkbuf_4
XTAP_TAPCELL_ROW_12_120 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_8_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_35_201 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xhold5 net129 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__dlygate4sd3_1
X_915_ clknet_3_2__leaf_clk _056_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dfxtp_1
X_846_ _421_ VGND VGND VPWR VPWR _422_ sky130_fd_sc_hd__clkbuf_2
X_777_ net142 _000_ _382_ VGND VGND VPWR VPWR _037_ sky130_fd_sc_hd__o21a_1
XFILLER_0_20_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_700_ _314_ _315_ _088_ VGND VGND VPWR VPWR _316_ sky130_fd_sc_hd__o21ai_1
X_562_ net176 _101_ _190_ _191_ _098_ VGND VGND VPWR VPWR _013_ sky130_fd_sc_hd__o221a_1
X_493_ _126_ _129_ VGND VGND VPWR VPWR _130_ sky130_fd_sc_hd__nor2_1
X_631_ _252_ _253_ VGND VGND VPWR VPWR _254_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_829_ net148 _404_ _412_ VGND VGND VPWR VPWR _059_ sky130_fd_sc_hd__o21a_1
XFILLER_0_31_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_476_ _111_ _114_ VGND VGND VPWR VPWR _115_ sky130_fd_sc_hd__nand2_1
X_545_ net102 _101_ _174_ _176_ _098_ VGND VGND VPWR VPWR _011_ sky130_fd_sc_hd__o221a_1
X_614_ net110 _238_ _087_ VGND VGND VPWR VPWR _239_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_9_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_6_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_459_ net66 _075_ VGND VGND VPWR VPWR _099_ sky130_fd_sc_hd__nor2_2
X_528_ net101 net31 VGND VGND VPWR VPWR _161_ sky130_fd_sc_hd__or2_1
Xoutput115 net115 VGND VGND VPWR VPWR product[53] sky130_fd_sc_hd__clkbuf_4
Xoutput104 net104 VGND VGND VPWR VPWR product[43] sky130_fd_sc_hd__clkbuf_4
Xoutput126 net126 VGND VGND VPWR VPWR product[63] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_18_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_33_195 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_33_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_24_162 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput39 mplier[15] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_1
Xinput28 mcand[5] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__buf_1
Xinput17 mcand[24] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_1
XFILLER_0_2_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_931_ clknet_3_3__leaf_clk _072_ VGND VGND VPWR VPWR cnt_act\[5\] sky130_fd_sc_hd__dfxtp_1
X_862_ clknet_3_6__leaf_clk _003_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dfxtp_1
X_793_ net157 _390_ _391_ VGND VGND VPWR VPWR _044_ sky130_fd_sc_hd__o21a_1
XTAP_TAPCELL_ROW_12_121 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_201 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_19_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_35_202 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_9_Left_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_776_ net55 _373_ _378_ net100 _379_ VGND VGND VPWR VPWR _382_ sky130_fd_sc_hd__a221o_1
X_914_ clknet_3_0__leaf_clk _055_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dfxtp_1
Xhold6 net75 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__dlygate4sd3_1
X_845_ cnt_act\[0\] _099_ _084_ VGND VGND VPWR VPWR _421_ sky130_fd_sc_hd__and3_1
XFILLER_0_20_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_630_ _242_ _246_ _243_ VGND VGND VPWR VPWR _253_ sky130_fd_sc_hd__a21oi_1
X_492_ _111_ _114_ _127_ _119_ _128_ VGND VGND VPWR VPWR _129_ sky130_fd_sc_hd__a311o_2
X_561_ net105 _175_ _080_ VGND VGND VPWR VPWR _191_ sky130_fd_sc_hd__a21o_1
X_828_ net49 _402_ _406_ net84 _407_ VGND VGND VPWR VPWR _412_ sky130_fd_sc_hd__a221o_1
X_759_ acu_act\[64\] _100_ _087_ VGND VGND VPWR VPWR _369_ sky130_fd_sc_hd__a21o_1
XFILLER_0_25_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_613_ _234_ _237_ VGND VGND VPWR VPWR _238_ sky130_fd_sc_hd__xor2_1
X_544_ net103 _175_ _080_ VGND VGND VPWR VPWR _176_ sky130_fd_sc_hd__a21o_1
X_475_ _112_ _113_ VGND VGND VPWR VPWR _114_ sky130_fd_sc_hd__and2_1
XFILLER_0_22_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_26_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_85 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_13_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_36_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XPHY_EDGE_ROW_22_Left_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_527_ _129_ _156_ _159_ VGND VGND VPWR VPWR _160_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_12_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_458_ _088_ _090_ _096_ _098_ VGND VGND VPWR VPWR _002_ sky130_fd_sc_hd__o211a_1
Xoutput116 net116 VGND VGND VPWR VPWR product[54] sky130_fd_sc_hd__buf_2
Xoutput105 net105 VGND VGND VPWR VPWR product[44] sky130_fd_sc_hd__clkbuf_4
Xoutput127 net127 VGND VGND VPWR VPWR product[6] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_33_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput18 mcand[25] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_24_163 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xinput29 mcand[6] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_2
XTAP_TAPCELL_ROW_15_130 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_23_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_930_ clknet_3_3__leaf_clk _071_ VGND VGND VPWR VPWR cnt_act\[4\] sky130_fd_sc_hd__dfxtp_1
X_792_ net64 _388_ _378_ net139 _379_ VGND VGND VPWR VPWR _391_ sky130_fd_sc_hd__a221o_1
X_861_ clknet_3_6__leaf_clk _002_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dfxtp_1
XTAP_TAPCELL_ROW_12_122 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XPHY_EDGE_ROW_25_Left_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_913_ clknet_3_2__leaf_clk _054_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dfxtp_1
Xhold7 net77 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__dlygate4sd3_1
X_775_ net146 _000_ _381_ VGND VGND VPWR VPWR _036_ sky130_fd_sc_hd__o21a_1
X_844_ _100_ _084_ net141 VGND VGND VPWR VPWR _420_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_29_96 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_0_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_560_ _188_ _189_ VGND VGND VPWR VPWR _190_ sky130_fd_sc_hd__nor2_1
X_491_ net94 net23 _127_ VGND VGND VPWR VPWR _128_ sky130_fd_sc_hd__and3_1
XFILLER_0_19_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_827_ net152 _404_ _411_ VGND VGND VPWR VPWR _058_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_689_ net118 net17 VGND VGND VPWR VPWR _306_ sky130_fd_sc_hd__nor2_1
X_758_ _353_ _363_ _366_ _094_ VGND VGND VPWR VPWR _368_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_155 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_543_ _094_ VGND VGND VPWR VPWR _175_ sky130_fd_sc_hd__clkbuf_4
X_612_ _235_ _236_ VGND VGND VPWR VPWR _237_ sky130_fd_sc_hd__nand2_1
X_474_ net94 net23 VGND VGND VPWR VPWR _113_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_27_172 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_526_ net99 net30 _155_ _157_ _158_ VGND VGND VPWR VPWR _159_ sky130_fd_sc_hd__a221o_1
X_457_ _097_ VGND VGND VPWR VPWR _098_ sky130_fd_sc_hd__clkbuf_4
Xoutput128 net128 VGND VGND VPWR VPWR product[7] sky130_fd_sc_hd__clkbuf_4
Xoutput106 net106 VGND VGND VPWR VPWR product[45] sky130_fd_sc_hd__clkbuf_4
Xoutput117 net117 VGND VGND VPWR VPWR product[55] sky130_fd_sc_hd__clkbuf_4
Xinput19 mcand[26] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__buf_1
XTAP_TAPCELL_ROW_24_164 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_15_131 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_509_ _135_ _138_ _143_ VGND VGND VPWR VPWR _144_ sky130_fd_sc_hd__a21oi_1
X_791_ _078_ VGND VGND VPWR VPWR _390_ sky130_fd_sc_hd__clkbuf_4
X_860_ clknet_3_3__leaf_clk _001_ VGND VGND VPWR VPWR estado_act\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_18_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_843_ net163 _078_ _419_ VGND VGND VPWR VPWR _066_ sky130_fd_sc_hd__o21a_1
X_912_ clknet_3_2__leaf_clk net168 VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dfxtp_1
Xhold8 net111 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__dlygate4sd3_1
X_774_ net44 _373_ _378_ net142 _379_ VGND VGND VPWR VPWR _381_ sky130_fd_sc_hd__a221o_1
XFILLER_0_17_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_490_ net95 net26 VGND VGND VPWR VPWR _127_ sky130_fd_sc_hd__or2_1
XFILLER_0_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_826_ net48 _402_ _406_ net148 _407_ VGND VGND VPWR VPWR _411_ sky130_fd_sc_hd__a221o_1
XFILLER_0_15_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_15_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_688_ net118 net17 VGND VGND VPWR VPWR _305_ sky130_fd_sc_hd__and2_1
X_757_ _353_ _363_ _366_ VGND VGND VPWR VPWR _367_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_17_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_21 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_76 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_473_ net94 net23 VGND VGND VPWR VPWR _112_ sky130_fd_sc_hd__or2_1
X_542_ _171_ _172_ _173_ VGND VGND VPWR VPWR _174_ sky130_fd_sc_hd__a21oi_1
X_611_ net109 net8 VGND VGND VPWR VPWR _236_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_112 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_22_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_809_ net173 _390_ _400_ VGND VGND VPWR VPWR _051_ sky130_fd_sc_hd__o21a_1
XFILLER_0_9_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_9_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_456_ net65 _075_ VGND VGND VPWR VPWR _097_ sky130_fd_sc_hd__nand2_1
XTAP_TAPCELL_ROW_27_173 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_525_ net99 net30 net29 net98 VGND VGND VPWR VPWR _158_ sky130_fd_sc_hd__o211a_1
Xoutput107 net107 VGND VGND VPWR VPWR product[46] sky130_fd_sc_hd__clkbuf_4
Xoutput129 net129 VGND VGND VPWR VPWR product[8] sky130_fd_sc_hd__clkbuf_4
Xoutput118 net118 VGND VGND VPWR VPWR product[56] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_18_140 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_439_ net67 VGND VGND VPWR VPWR _081_ sky130_fd_sc_hd__inv_2
XTAP_TAPCELL_ROW_15_132 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_508_ net97 net28 VGND VGND VPWR VPWR _143_ sky130_fd_sc_hd__nor2_1
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_6_100 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_790_ net135 _000_ _389_ VGND VGND VPWR VPWR _043_ sky130_fd_sc_hd__o21a_1
X_842_ net57 _372_ _377_ net92 _077_ VGND VGND VPWR VPWR _419_ sky130_fd_sc_hd__a221o_1
Xhold9 net68 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__dlygate4sd3_1
X_911_ clknet_3_3__leaf_clk _052_ VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dfxtp_1
X_773_ net166 _000_ _380_ VGND VGND VPWR VPWR _035_ sky130_fd_sc_hd__o21a_1
XFILLER_0_20_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_29_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_9 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_28_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_825_ net174 _404_ _410_ VGND VGND VPWR VPWR _057_ sky130_fd_sc_hd__o21a_1
X_756_ _364_ _365_ VGND VGND VPWR VPWR _366_ sky130_fd_sc_hd__and2_1
X_687_ _272_ _301_ _303_ VGND VGND VPWR VPWR _304_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_25_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_31_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_88 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_121 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_610_ net109 net8 VGND VGND VPWR VPWR _235_ sky130_fd_sc_hd__or2_1
X_472_ _091_ _110_ _103_ VGND VGND VPWR VPWR _111_ sky130_fd_sc_hd__o21ai_1
X_541_ _171_ _172_ _088_ VGND VGND VPWR VPWR _173_ sky130_fd_sc_hd__o21ai_1
X_808_ net40 _388_ _392_ net136 _393_ VGND VGND VPWR VPWR _400_ sky130_fd_sc_hd__a221o_1
X_739_ _348_ _349_ _350_ VGND VGND VPWR VPWR _351_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_12_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_455_ _091_ _092_ _095_ VGND VGND VPWR VPWR _096_ sky130_fd_sc_hd__a21o_1
XTAP_TAPCELL_ROW_27_174 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_524_ _124_ _135_ _143_ VGND VGND VPWR VPWR _157_ sky130_fd_sc_hd__a21oi_1
Xoutput108 net108 VGND VGND VPWR VPWR product[47] sky130_fd_sc_hd__clkbuf_4
Xoutput119 net119 VGND VGND VPWR VPWR product[57] sky130_fd_sc_hd__clkbuf_4
Xoutput90 net90 VGND VGND VPWR VPWR product[30] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_18_141 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_187 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_5_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_438_ _079_ VGND VGND VPWR VPWR _080_ sky130_fd_sc_hd__clkbuf_4
X_507_ net98 net29 VGND VGND VPWR VPWR _142_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_6_101 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_1_190 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_18_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_88 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_910_ clknet_3_2__leaf_clk _051_ VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__dfxtp_1
X_841_ net149 _078_ _418_ VGND VGND VPWR VPWR _065_ sky130_fd_sc_hd__o21a_1
X_772_ net33 _373_ _378_ net78 _379_ VGND VGND VPWR VPWR _380_ sky130_fd_sc_hd__a221o_1
XFILLER_0_29_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_29_Left_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_174 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_9_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_34_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_824_ net47 _402_ _406_ net82 _407_ VGND VGND VPWR VPWR _410_ sky130_fd_sc_hd__a221o_1
X_755_ net126 net25 VGND VGND VPWR VPWR _365_ sky130_fd_sc_hd__nand2_1
XFILLER_0_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_686_ _285_ _293_ _300_ _302_ _294_ VGND VGND VPWR VPWR _303_ sky130_fd_sc_hd__o221a_1
XFILLER_0_25_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_25_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xclkbuf_3_5__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_5__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_16_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_540_ _160_ _163_ _162_ VGND VGND VPWR VPWR _172_ sky130_fd_sc_hd__o21a_1
X_471_ net93 net12 VGND VGND VPWR VPWR _110_ sky130_fd_sc_hd__nor2_1
XFILLER_0_22_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_22_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_807_ net140 _390_ _399_ VGND VGND VPWR VPWR _050_ sky130_fd_sc_hd__o21a_1
X_738_ _348_ _349_ _088_ VGND VGND VPWR VPWR _350_ sky130_fd_sc_hd__o21ai_1
X_669_ _277_ _281_ _278_ VGND VGND VPWR VPWR _288_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_16_Left_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_3 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_523_ _126_ _135_ _136_ _155_ VGND VGND VPWR VPWR _156_ sky130_fd_sc_hd__and4_1
X_454_ _094_ VGND VGND VPWR VPWR _095_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_27_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XTAP_TAPCELL_ROW_2_84 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_10_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput109 net109 VGND VGND VPWR VPWR product[48] sky130_fd_sc_hd__clkbuf_4
Xoutput80 net80 VGND VGND VPWR VPWR product[21] sky130_fd_sc_hd__clkbuf_4
Xoutput91 net91 VGND VGND VPWR VPWR product[31] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_18_142 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_5_199 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_1_Left_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XTAP_TAPCELL_ROW_9_110 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_23_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_506_ net97 _101_ _140_ _141_ _098_ VGND VGND VPWR VPWR _007_ sky130_fd_sc_hd__o221a_1
X_437_ net66 _075_ VGND VGND VPWR VPWR _079_ sky130_fd_sc_hd__or2_1
XFILLER_0_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_840_ net56 _372_ _377_ net91 _077_ VGND VGND VPWR VPWR _418_ sky130_fd_sc_hd__a221o_1
X_771_ _077_ VGND VGND VPWR VPWR _379_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_4_Left_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_30_Left_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_823_ net158 _404_ _409_ VGND VGND VPWR VPWR _056_ sky130_fd_sc_hd__o21a_1
X_754_ net126 net25 VGND VGND VPWR VPWR _364_ sky130_fd_sc_hd__or2_1
X_685_ _266_ _277_ _278_ VGND VGND VPWR VPWR _302_ sky130_fd_sc_hd__a21o_1
XFILLER_0_31_57 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_5_95 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_15_6 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_470_ net95 net94 _079_ VGND VGND VPWR VPWR _109_ sky130_fd_sc_hd__mux2_1
X_806_ net39 _388_ _392_ net74 _393_ VGND VGND VPWR VPWR _399_ sky130_fd_sc_hd__a221o_1
XFILLER_0_30_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_737_ _338_ _341_ _340_ VGND VGND VPWR VPWR _349_ sky130_fd_sc_hd__o21a_1
X_668_ _285_ _286_ VGND VGND VPWR VPWR _287_ sky130_fd_sc_hd__nand2_1
X_599_ _222_ _216_ _223_ _094_ VGND VGND VPWR VPWR _225_ sky130_fd_sc_hd__a31o_1
XFILLER_0_6_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_197 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_170 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_453_ _093_ VGND VGND VPWR VPWR _094_ sky130_fd_sc_hd__clkbuf_4
X_522_ _142_ _149_ VGND VGND VPWR VPWR _155_ sky130_fd_sc_hd__and2b_1
XFILLER_0_12_37 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_85 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput70 net70 VGND VGND VPWR VPWR product[12] sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_33_Left_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput81 net81 VGND VGND VPWR VPWR product[22] sky130_fd_sc_hd__clkbuf_4
Xoutput92 net92 VGND VGND VPWR VPWR product[32] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_18_143 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_32_190 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_9_111 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_436_ _078_ VGND VGND VPWR VPWR _000_ sky130_fd_sc_hd__clkbuf_4
X_505_ net98 _095_ _080_ VGND VGND VPWR VPWR _141_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_770_ _377_ VGND VGND VPWR VPWR _378_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_20_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_899_ clknet_3_6__leaf_clk _040_ VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_34_168 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_822_ net46 _402_ _406_ net81 _407_ VGND VGND VPWR VPWR _409_ sky130_fd_sc_hd__a221o_1
X_753_ _355_ _357_ VGND VGND VPWR VPWR _363_ sky130_fd_sc_hd__or2_1
X_684_ _267_ _280_ _300_ VGND VGND VPWR VPWR _301_ sky130_fd_sc_hd__or3_1
XTAP_TAPCELL_ROW_5_96 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_805_ net155 _390_ _398_ VGND VGND VPWR VPWR _049_ sky130_fd_sc_hd__o21a_1
X_736_ _346_ _347_ VGND VGND VPWR VPWR _348_ sky130_fd_sc_hd__nand2_1
X_667_ net116 net15 VGND VGND VPWR VPWR _286_ sky130_fd_sc_hd__or2_1
X_598_ _222_ _216_ _223_ VGND VGND VPWR VPWR _224_ sky130_fd_sc_hd__a21oi_1
XANTENNA_1 net23 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_35 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_12_182 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_452_ _081_ estado_act\[1\] estado_act\[0\] VGND VGND VPWR VPWR _093_ sky130_fd_sc_hd__or3b_1
X_521_ net177 _101_ _153_ _154_ _098_ VGND VGND VPWR VPWR _009_ sky130_fd_sc_hd__o221a_1
XFILLER_0_12_49 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XTAP_TAPCELL_ROW_2_86 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput82 net82 VGND VGND VPWR VPWR product[23] sky130_fd_sc_hd__clkbuf_4
Xoutput93 net93 VGND VGND VPWR VPWR product[33] sky130_fd_sc_hd__clkbuf_4
Xoutput71 net71 VGND VGND VPWR VPWR product[13] sky130_fd_sc_hd__buf_2
X_719_ _321_ _327_ VGND VGND VPWR VPWR _332_ sky130_fd_sc_hd__nor2_1
XTAP_TAPCELL_ROW_32_191 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_4_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_435_ _077_ VGND VGND VPWR VPWR _078_ sky130_fd_sc_hd__inv_2
XFILLER_0_23_15 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_504_ _137_ _138_ _139_ VGND VGND VPWR VPWR _140_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_3_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XTAP_TAPCELL_ROW_20_150 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_11_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_24_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_898_ clknet_3_0__leaf_clk _039_ VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_821_ net147 _404_ _408_ VGND VGND VPWR VPWR _055_ sky130_fd_sc_hd__o21a_1
X_752_ net164 _080_ VGND VGND VPWR VPWR _362_ sky130_fd_sc_hd__nand2_1
X_683_ _287_ _295_ VGND VGND VPWR VPWR _300_ sky130_fd_sc_hd__or2_1
XTAP_TAPCELL_ROW_5_97 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_25_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_70 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_31_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_804_ net38 _388_ _392_ net73 _393_ VGND VGND VPWR VPWR _398_ sky130_fd_sc_hd__a221o_1
X_735_ net124 net22 VGND VGND VPWR VPWR _347_ sky130_fd_sc_hd__nand2_1
X_666_ net116 net15 VGND VGND VPWR VPWR _285_ sky130_fd_sc_hd__nand2_1
X_597_ net108 net7 VGND VGND VPWR VPWR _223_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_139 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XANTENNA_2 net99 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
X_520_ net101 _095_ _080_ VGND VGND VPWR VPWR _154_ sky130_fd_sc_hd__a21o_1
X_451_ net92 net1 VGND VGND VPWR VPWR _092_ sky130_fd_sc_hd__or2_1
Xoutput83 net83 VGND VGND VPWR VPWR product[24] sky130_fd_sc_hd__buf_2
XTAP_TAPCELL_ROW_2_87 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
Xoutput94 net94 VGND VGND VPWR VPWR product[34] sky130_fd_sc_hd__clkbuf_4
Xoutput72 net72 VGND VGND VPWR VPWR product[14] sky130_fd_sc_hd__clkbuf_4
X_718_ net121 _100_ _330_ _331_ _102_ VGND VGND VPWR VPWR _029_ sky130_fd_sc_hd__o221a_1
X_649_ _236_ _242_ _243_ VGND VGND VPWR VPWR _270_ sky130_fd_sc_hd__a21o_1
XFILLER_0_5_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_27_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XTAP_TAPCELL_ROW_32_192 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
X_503_ _137_ _138_ _088_ VGND VGND VPWR VPWR _139_ sky130_fd_sc_hd__o21ai_1
X_434_ _074_ _075_ _076_ VGND VGND VPWR VPWR _077_ sky130_fd_sc_hd__a21bo_2
XFILLER_0_23_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_13_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_897_ clknet_3_0__leaf_clk _038_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_0_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_28_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XPHY_EDGE_ROW_8_Left_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_3_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_820_ net45 _402_ _406_ net80 _407_ VGND VGND VPWR VPWR _408_ sky130_fd_sc_hd__a221o_1
X_751_ _361_ VGND VGND VPWR VPWR _032_ sky130_fd_sc_hd__clkbuf_1
X_682_ net117 _100_ _298_ _299_ _102_ VGND VGND VPWR VPWR _025_ sky130_fd_sc_hd__o221a_1
XFILLER_0_15_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_33_181 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_21_82 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XFILLER_0_24_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_803_ net161 _390_ _397_ VGND VGND VPWR VPWR _048_ sky130_fd_sc_hd__o21a_1
Xhold50 net111 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__dlygate4sd3_1
X_734_ net124 net22 VGND VGND VPWR VPWR _346_ sky130_fd_sc_hd__or2_1
XFILLER_0_26_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_665_ net115 _100_ _283_ _284_ _102_ VGND VGND VPWR VPWR _023_ sky130_fd_sc_hd__o221a_1
X_596_ net107 net6 VGND VGND VPWR VPWR _222_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_450_ net92 net1 VGND VGND VPWR VPWR _091_ sky130_fd_sc_hd__nand2_1
Xoutput95 net95 VGND VGND VPWR VPWR product[35] sky130_fd_sc_hd__buf_2
Xoutput73 net73 VGND VGND VPWR VPWR product[15] sky130_fd_sc_hd__clkbuf_4
Xoutput84 net84 VGND VGND VPWR VPWR product[25] sky130_fd_sc_hd__clkbuf_4
X_717_ net123 _175_ _089_ VGND VGND VPWR VPWR _331_ sky130_fd_sc_hd__a21o_1
X_648_ _252_ _260_ VGND VGND VPWR VPWR _269_ sky130_fd_sc_hd__or2_1
X_579_ net106 net5 VGND VGND VPWR VPWR _207_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
X_433_ estado_act\[1\] net67 estado_act\[0\] VGND VGND VPWR VPWR _076_ sky130_fd_sc_hd__o21ai_1
X_502_ _126_ _129_ _124_ VGND VGND VPWR VPWR _138_ sky130_fd_sc_hd__a21boi_1
XPHY_EDGE_ROW_21_Left_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XTAP_TAPCELL_ROW_23_160 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XTAP_TAPCELL_ROW_12_119 VGND VPWR sky130_fd_sc_hd__tapvpwrvgnd_1
XFILLER_0_34_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_4_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_896_ clknet_3_0__leaf_clk _037_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_124 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
XPHY_EDGE_ROW_24_Left_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_19_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_2
XFILLER_0_15_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_750_ _097_ _360_ VGND VGND VPWR VPWR _361_ sky130_fd_sc_hd__and2_1
X_681_ net118 _175_ _089_ VGND VGND VPWR VPWR _299_ sky130_fd_sc_hd__a21o_1
XFILLER_0_25_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_193 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
X_879_ clknet_3_7__leaf_clk _020_ VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_21_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_182 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xhold40 _062_ VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__dlygate4sd3_1
X_802_ net37 _388_ _392_ net72 _393_ VGND VGND VPWR VPWR _397_ sky130_fd_sc_hd__a221o_1
XFILLER_0_30_141 VGND VPWR VPWR VGND sky130_ef_sc_hd__decap_12
Xhold51 net130 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__dlygate4sd3_1
X_733_ _345_ VGND VGND VPWR VPWR _030_ sky130_fd_sc_hd__clkbuf_1
X_664_ net116 _175_ _089_ VGND VGND VPWR VPWR _284_ sky130_fd_sc_hd__a21o_1
X_595_ _221_ VGND VGND VPWR VPWR _016_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
XFILLER_0_8_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__fill_1
Xoutput74 net74 VGND VGND VPWR VPWR product[16] sky130_fd_sc_hd__clkbuf_4
Xoutput85 net85 VGND VGND VPWR VPWR product[26] sky130_fd_sc_hd__clkbuf_4
Xoutput96 net96 VGND VGND VPWR VPWR product[36] sky130_fd_sc_hd__clkbuf_4
X_716_ _095_ _329_ VGND VGND VPWR VPWR _330_ sky130_fd_sc_hd__nor2_1
X_578_ _206_ VGND VGND VPWR VPWR _014_ sky130_fd_sc_hd__clkbuf_1
X_647_ _237_ _245_ VGND VGND VPWR VPWR _268_ sky130_fd_sc_hd__or2_1
.ends
